# Keil uVision project TorchSensor.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 2810-3testt +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\HARDWARE\ADXL345;.\HARDWARE\IIC;.\HARDWARE\TaskMgr;.\HARDWARE\TIMER;.\HARDWARE\USART2;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\USER\TaskMgr;.\HARDWARE\NRF24L01;.\HARDWARE\SPI;.\USER;.\HARDWARE\CodeModule;.\HARDWARE\MLX90614;.\HARDWARE\UART4;.\USER\APP;.\HARDWARE\CAN;.\HARDWARE\LED;.\HARDWARE\FLASH;.\HARDWARE\CH454;.\HARDWARE\KEY;.\HARDWARE\OLED;.\STM32F10x_FWLib\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../../../../Hfile/: DailyRecord.h library.h LinuxStudy.h NeverStopStudying.h
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
    ../../../../: NeverStopStudying.h
  group HARDWARE
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/UART4/: usart.c
    ./HARDWARE/FLASH/: stmflash.c
    ./HARDWARE/CAN/: can.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/OLED/: oled.c ShowInterface.c pic.c
  group USER
    ./HARDWARE/LED/: led.c
    ./USER/TaskMgr/: TaskMgr.c
    ./USER/: main.c
    ./USER/APP/: UAPP_CAN.c UAPP_Comm.c UAPP_Senser.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1, Device:Startup 1.0.0
